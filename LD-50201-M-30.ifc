Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-11-16T04:55:27
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (8)
Name | FlowDirection
4 x  | SOURCE
4 x  | SINK

# IfcFlowTerminal: LADOR 42 Floodlights,projectors
In: Default Building
Type - Description: - Lamp LED - Colour RGBW30, RGBW40 - Die-cast aluminium housing - Pre-treated before powder coating ensuring high corrosion resistance - Thermal heat dissipation body - Adjustable: Tilt 80° (Up) & 40° (Down), Rotation 350° - Single cable entry - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - High-efficiency PMMA lens - Clear toughened glass - Remote driver (included); PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: LADOR, Floodlights,projectors; Housing color: Not specified
General Information - Article number: LD-50201-M-30; Article name: LADOR 42 Floodlights,projectors; Weight: 1.4 kg; Case length: 6.2 cm; Case width: 6.2 cm; Case height: 21.2 cm; Uld creation date: 16.11.2024 03:55:27
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 7.2 W
Pset_LightFixtureTypeCommon - NumberOfSources: 4; TotalWattage: 2 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN

# IfcFlowTerminal: LD-50201-M-B
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: LD-50201-M-B; Light output ratio: 1; Luminous flux: 64.3384 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 14.8283 lm; LightEmitterNominalPower: 1.8 W; Spectrum: 380: 15, 385: 12, 390: 1, 395: 9, 400: 9, 405: 8, 410: 28, 415: 769, 420: 3775, 425: 1037, 430: 26623, 435: 56111, 440: 118825, 445: 22184, 450: 388447, 455: 674983, 460: 987042, 465: 1052478, 470: 896258, 475: 71852, 480: 5464, 485: 372007, 490: 254137, 495: 171549, 500: 113108, 505: 74894, 510: 49984, 515: 34254, 520: 22855, 525: 15103, 530: 10572, 535: 7431, 540: 4725, 545: 3443, 550: 2247, 555: 1246, 560: 1384, 565: 625, 570: 233, 575: 309, 580: 154, 585: 0, 590: 13, 595: 369, 600: 24, 605: 1, 610: 9, 615: 8, 620: 1, 625: 11, 630: 0, 635: 14, 640: 0, 645: 0, 650: 0, 655: 26, 660: 4, 665: 255, 670: 25, 675: 11, 680: 11, 685: 11, 690: 11, 695: 12, 700: 7, 705: 302, 710: 432, 715: 49, 720: 13, 725: 14, 730: 15, 735: 25, 740: 556, 745: 0, 750: 234, 755: 0, 760: 22, 765: 23, 770: 27, 775: 28, 780: 31

# IfcFlowTerminal: LD-50201-M-G
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: LD-50201-M-G; Light output ratio: 1; Luminous flux: 64.3384 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 69.8592 lm; LightEmitterNominalPower: 1.9 W; Spectrum: 380: 1942, 385: 0, 390: 2385, 395: 0, 400: 117, 405: 669, 410: 51, 415: 0, 420: 946, 425: 196, 430: 0, 435: 1161, 440: 303, 445: 3161, 450: 2805, 455: 5179, 460: 5681, 465: 9363, 470: 16603, 475: 35501, 480: 69058, 485: 126841, 490: 208672, 495: 335484, 500: 531351, 505: 809043, 510: 1097549, 515: 130022, 520: 138858, 525: 1326776, 530: 1130511, 535: 922711, 540: 721425, 545: 557469, 550: 432042, 555: 330862, 560: 249007, 565: 186634, 570: 137761, 575: 101362, 580: 73883, 585: 54769, 590: 41297, 595: 32927, 600: 22431, 605: 19034, 610: 12097, 615: 879, 620: 895, 625: 7762, 630: 5623, 635: 365, 640: 2034, 645: 1532, 650: 1614, 655: 62, 660: 0, 665: 116, 670: 1848, 675: 279, 680: 1733, 685: 151, 690: 0, 695: 1658, 700: 105, 705: 0, 710: 288, 715: 687, 720: 1082, 725: 145, 730: 23, 735: 44, 740: 991, 745: 19, 750: 31, 755: 33, 760: 36, 765: 2, 770: 2076, 775: 284, 780: 63

# IfcFlowTerminal: LD-50201-M-R
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: LD-50201-M-R; Light output ratio: 1; Luminous flux: 64.3384 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 42.921 lm; LightEmitterNominalPower: 1.5 W; Spectrum: 380: 2732, 385: 1636, 390: 446, 395: 0, 400: 3259, 405: 43, 410: 67, 415: 8, 420: 784, 425: 6957, 430: 135, 435: 1308, 440: 9081, 445: 0, 450: 9, 455: 1087, 460: 687, 465: 598, 470: 6609, 475: 92, 480: 663, 485: 0, 490: 146, 495: 39, 500: 851, 505: 1252, 510: 112, 515: 5823, 520: 154, 525: 725, 530: 5191, 535: 2225, 540: 3952, 545: 0, 550: 44, 555: 4258, 560: 3464, 565: 3893, 570: 10965, 575: 23605, 580: 46391, 585: 93667, 590: 155921, 595: 276011, 600: 492912, 605: 860002, 610: 1531215, 615: 2556221, 620: 4039036, 625: 6285856, 630: 8094158, 635: 6087111, 640: 2945096, 645: 1238895, 650: 555234, 655: 299846, 660: 194193, 665: 122602, 670: 88499, 675: 75667, 680: 53426, 685: 47708, 690: 33622, 695: 24902, 700: 16338, 705: 543, 710: 14221, 715: 8547, 720: 11231, 725: 3263, 730: 1564, 735: 0, 740: 14794, 745: 1883, 750: 24508, 755: 3014, 760: 15277, 765: 21694, 770: 13646, 775: 165, 780: 223

# IfcFlowTerminal: LD-50201-M-W30
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: LD-50201-M-W30; Light output ratio: 1; Luminous flux: 64.3384 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 64.3384 lm; LightEmitterNominalPower: 2 W; Spectrum: 380: 3690569940095, 385: 4417827229087, 390: 103848623026, 395: 2413660876001, 400: 1635812461327, 405: 4979578862755, 410: 12008388049112, 415: 19010183755416, 420: 43492384284535, 425: 92387686399588, 430: 170081055352913, 435: 269257868050557, 440: 40380870835791, 445: 53053129979791, 450: 541210894212732, 455: 426035362969713, 460: 319709451836581, 465: 266258975756854, 470: 226744256316502, 475: 207655744220688, 480: 216725827235634, 485: 242313897411951, 490: 279103409927536, 495: 328329280608539, 500: 378364184545817, 505: 420767841360709, 510: 462021280818343, 515: 499628684012278, 520: 53600339508975, 525: 569109151908192, 530: 601715266536285, 535: 639788059693626, 540: 661953558922068, 545: 700811371799149, 550: 726341656016481, 555: 763989655672423, 560: 798739391155653, 565: 823807606707386, 570: 857424658565251, 575: 884129681820959, 580: 923657720451389, 585: 931100423923485, 590: 9394705544887, 595: 955178378620732, 600: 987139827132279, 605: 994081671981375, 610: 979624106749581, 615: 966308697952284, 620: 932083700929844, 625: 905082811260578, 630: 85331256109502, 635: 812867663499088, 640: 772044579830947, 645: 723717028028327, 650: 667977465880293, 655: 605503400426768, 660: 557213452509668, 665: 512777944144936, 670: 456803100163102, 675: 410601427321495, 680: 369369935082491, 685: 329151369897868, 690: 292549661602736, 695: 26125055859854, 700: 235075104418585, 705: 201009171723973, 710: 171700611576055, 715: 153226696188552, 720: 134667771647789, 725: 105256592587452, 730: 9695868067302, 735: 84328451897198, 740: 75702721075612, 745: 61935410416435, 750: 55940253582514, 755: 47738579126093, 760: 40479643762502, 765: 36799415163306, 770: 29784469641817, 775: 28115994214981, 780: 32447745650972; ColorTemperature: 3000 K; ColorRenderingIndex: 80
